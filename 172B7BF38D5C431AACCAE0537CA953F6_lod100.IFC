Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
File name: C:\inetpub\wwwroot\LDAWP_Outbound\172B7BF38D5C431AACCAE0537CA953F6_lod100.IFC
Time: 2022-09-27T12:01:26
Made in: DigiPara Liftdesigner

# IfcBuilding, Document
LongName: Document
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.CreatedBy: INFO@ARITCO.COM; COBie.Type.NominalHeight: 5290 mm; COBie.Type.NominalLength: 1473 mm; COBie.Type.NominalWidth: 1600 mm
DigiPara - DigiPara.IfcExportAs: IfcBuilding; DigiPara.IfcExportType: ELEVATOR; DigiPara.LDXType: LDXDocument; DigiPara.RevitTargetName: LDXDocument
Pset_TransportElementElevator - ClearDepth: 1100 mm; ClearHeight: 0 mm; ClearWidth: 1480 mm
ARITCO Web Configurator - URL: https://liftguide.aritco.com/?a=1100x1480&m=7000&dt=large&f=delta_dark_grey_vinyl&ch1=2240&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&wg=hide&wa0=sheet&wb0=sheet&wc0=sheet&wa1=sheet&wb1=sheet&wc1=sheet&wa2=sheet&wb2=sheet&wc2=sheet&wa3=sheet&wb3=sheet&wc3=sheet&wa4=sheet&wb4=sheet&wc4=sheet&wa5=sheet&wb5=sheet&wc5=sheet&dp0=B

# IfcBuildingSystem: Shaft Frame, ARITCO - PublicLift Access: PublicLift Access - MR Rear
PredefinedType: TRANSPORT; LongName: ARITCO - PublicLift Access: PublicLift Access - MR Rear
UK.COBie.Type - COBie.Type.Category: EF_80_50: Lifts; COBie.Type.Color: Traffic white; COBie.Type.CreatedBy: INFO@ARITCO.COM; COBie.Type.Description: Shaft Frame; COBie.Type.Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; COBie.Type.NominalHeight: 5290 mm; COBie.Type.NominalLength: 1473 mm; COBie.Type.NominalWidth: 1600 mm; COBie.Type.Size: 1473X1600
DigiPara - DigiPara.IfcExportAs: IfcBuildingSystem; DigiPara.IfcExportType: ELEVATOR; DigiPara.IfcParent: Document.; DigiPara.LDXType: LDXShaft; DigiPara.RevitTargetName: LDXShaft
Revit Standard Parameter - Assembly Code: D1010; Description: Shaft Frame; Manufacturer: ARITCO - PUBLIC LIFT ACCESS SHAFT COMPONENTS; Model: Shaft Frame; OmniClass Number: 23.23.11.11; Type Comments: Shaft Frame
Pset_ManufacturerTypeInformation - ModelLabel: Shaft Frame
ARITCO Web Configurator - URL: https://liftguide.aritco.com/?a=1100x1480&m=7000&dt=large&f=delta_dark_grey_vinyl&ch1=2240&ch2=2400&ch3=2400&ch4=2400&ch5=2400&wh=half&wg=hide&wa0=sheet&wb0=sheet&wc0=sheet&wa1=sheet&wb1=sheet&wc1=sheet&wa2=sheet&wb2=sheet&wc2=sheet&wa3=sheet&wb3=sheet&wc3=sheet&wa4=sheet&wb4=sheet&wc4=sheet&wa5=sheet&wb5=sheet&wc5=sheet&dp0=B

# IfcSpatialZone: Shaft, Shaft0
In: Document
Description: Shaft; LongName: Hole0.; PredefinedType: OCCUPANCY; Group: ARITCO - PublicLift Access: PublicLift Access - MR Rear
